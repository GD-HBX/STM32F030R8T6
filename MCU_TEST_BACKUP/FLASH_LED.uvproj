# Keil uVision project FLASH_LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: FLASH_LED +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: FLASH_LED.sct
  group Source Group 1
    ./: main.c SYSCFG.c TEST.c
    ./my_lib/: startup.s
  group mokuai
    ./: NVIC.c EXTI.c CRC.c GPIOx.c RCC.c ADC.c TIMx.c RTC.c ASCII.c 24c02n.c
    ./my_lib/: I2C.c DMA.c USART1.c log.c SPI.c
